# Keil uVision project project.uvproj, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LM4F232H5BB Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: project
  AfterMake: fromelf --bin --output .\rvmdk\project.bin .\rvmdk\project.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F232H5BB TARGET_IS_BLIZZARD_RA3
  c misc: --c99
  c include: ..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: project.sct
  link misc: --entry Reset_Handler
  group Source
    ./: project.c startup_rvmdk.S
  group Libraries
    ../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
